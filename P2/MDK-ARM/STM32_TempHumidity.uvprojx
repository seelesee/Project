# Keil uVision project STM32_TempHumidity.uvprojx, settings and files
target STM32_TempHumidity (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000)
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..;../Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/STM32F1xx_HAL_Driver/Inc;../Core/Inc
  asm define: USE_HAL_DRIVER,STM32F103xB
  scatter file: .\STM32F103C8Tx_FLASH.sct
  group Application/User
    ../: main.c main.h
  group Drivers/Sensor
    ../Src/: dht22.c
    ../Inc/: dht22.h
  group Drivers/Display
    ../Src/: oled.c
    ../Inc/: oled.h oled_font.h
  group Drivers/Button
    ../Src/: button.c
    ../Inc/: button.h
  group Drivers/Buzzer
    ../Src/: buzzer.c
    ../Inc/: buzzer.h
  group Drivers/Protocol
    ../Src/: protocol.c
    ../Inc/: protocol.h
  group Drivers/Config
    ../Src/: config.c
    ../Inc/: config.h
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c
